## config/boards/shields/Dactyl_Manuform_6x7/Kconfig.defconfig
```kconfig
if SHIELD_MANUFORM_6X7

config ZMK_KEYBOARD_NAME
    default "Manuform_6x7"

endif
```
